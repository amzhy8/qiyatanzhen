# Keil uVision project XYGD_W02_20171031.uvprojx, settings and files
target XYGD_W02_20171031 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: XYGD_W02_20171031 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c misc: --C99
  c include: ../Inc;                                            ../Drivers/STM32F4xx_HAL_Driver/Inc;                                            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                            ../Drivers/CMSIS/Include;                                            ..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User
    ../bsp/src/: bsp_led.c bsp_uart.c bsp_UartProtocl.c bsp_Ad7606.c bsp_interal_flash.c bsp_time.c bsp_config.c bsp_calculation.c bsp_buildframe.c bsp_dmasend.c bsp_ms5540b.c bsp_adder.c
    ../Src/: spi.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.c usart.c gpio.c dma.c tim.c iwdg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_iwdg.c
software components: CMSIS:CORE 4.1.0
